# Keil uVision project flight_control.uvprojx, settings and files
target 407_temp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flight_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM\Timer;..\HARDWARE\BSP;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\usart_2;..\HARDWARE\usart_3;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\Control;..\HARDWARE\Contol_task;..\HARDWARE\NVIC_Int;..\HARDWARE\Pwm;..\HARDWARE\Key;..\HARDWARE\NRF24L01;..\HARDWARE\My_I2C;..\HARDWARE\Motor;..\HARDWARE\BMP280;..\HARDWARE\QMC5883P;..\HARDWARE\ADC;..\HARDWARE\NVIC_IRQ;..\HARDWARE\My_CAN
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/BSP/: Bsp.c
    ../HARDWARE/My_I2C/: My_I2C.c
    ../HARDWARE/Control/: Control.c
    ../HARDWARE/NVIC_IRQ/: NVIC_IRQ.c
    ../HARDWARE/Contol_task/: Contol_task.c
    ../HARDWARE/LC307/: LC307.c
    ../HARDWARE/Pwm/: Pwm.c
    ../HARDWARE/Motor/: Motor.c
    ../HARDWARE/usart_2/: usart_2.c usart_2.h
    ../HARDWARE/usart_3/: usart_3.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Key/: Key.c
    ../HARDWARE/OLED/: OLED.c OLED_Data.c
    ../HARDWARE/MPU6050/: mpu6050.c myiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/BMP280/: bmp280.c
    ../HARDWARE/QMC5883P/: QMC5883P.c
    ../HARDWARE/NVIC_Int/: NVIC_Int.c
    ../HARDWARE/NRF24L01/: NRF24L01.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/My_CAN/: My_can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/Timer/: Timer.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_can.c stm32f4xx_i2c.c stm32f4xx_adc.c
  group README
    ../: readme.txt
